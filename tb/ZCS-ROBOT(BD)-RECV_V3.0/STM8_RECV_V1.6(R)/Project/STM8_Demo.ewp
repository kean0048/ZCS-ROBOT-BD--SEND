# IAR project STM8_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $TOOLKIT_DIR$\inc\; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_Demo.hex
  ILINK.IlinkOutputFile: STM8_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: ADSample.c BusContrl.c Buzz.c Eeprom.c FAN_Control.c GL_charge_process.c MacProtect.c main.c Nrf24l01.c PWM_Control.c QueueMsg.c stm8s_interruput.c SysInit.c uart.c
