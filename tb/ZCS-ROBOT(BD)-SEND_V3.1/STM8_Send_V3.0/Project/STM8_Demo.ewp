# IAR project STM8_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x50
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_Demo.hex
  ILINK.IlinkOutputFile: STM8_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: ADSample.c Buzz.c Clock.c delayTime.c Eeprom.c FAN_Control.c MacProtect.c main.c Nrf24l01.c PWM_Control.c QueueMsg.c stm8s_interruput.c Stream2Char.c SysInit.c uart.c
